options:
  parameters:
    author: Trevor Wiseman
    category: Custom
    generate_options: qt_gui
    id: qpsk_signal_processing
    output_language: python
    title: qpsk_signal_processing
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: frequency offset'
    start: '-0.100'
    step: '0.001'
    stop: '0.100'
    value: '0.025'
  states: {}
- name: input_vector
  id: variable
  parameters:
    value: '[0,1,0,1]'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: Correlator_correlator_0
  id: Correlator_correlator
  parameters:
    sps: '2'
  states: {state: bypassed}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/trevorwiseman/Documents/GitHub/InternProj2025/GNU_Radio/testing/manual_processing/bits_read_in.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/trevorwiseman/Documents/GitHub/InternProj2025/GNU_Radio/testing/manual_processing/bits_to_send.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: input_vector
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: bypassed}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [Correlator_correlator_0, '0', blocks_file_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', Correlator_correlator_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
