options:
  parameters:
    generate_options: qt_gui
    id: idk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: data
  id: variable
  parameters:
    value: (0,1,0,0,1,0,0,0,0,1,1,0,0,1,0,1,0,1,1,0,1,1,0,0,0,1,1,0,1,1,0,0,0,1,1,0,1,1,1,1,0,0,1,0,0,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,1,1,1,1,0,1,1,1,0,0,1,0,0,1,1,0,1,1,0,0,0,1,1,0,0,1,0,0,0,0,1,0,0,0,0,1)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: marker
  id: variable
  parameters:
    value: (1,1,1,1,1,0,0,1,1,0,1,0,0,1,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,0,0,1)
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: int(40)
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/empire/Documents/InternProj2025/GNU_Radio/testing/bits_read_in.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: marker+data
  states: {}
- name: customModule_QPSK_Modulator_0
  id: customModule_QPSK_Modulator
  parameters: {}
  states: {}
- name: customModule_upsampler_0
  id: customModule_upsampler
  parameters:
    sps: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imaginary
    name: '"Tx"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imaginary
    name: '"Rx"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imaginary
    name: '"Tx"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: vsg60_iqin_0
  id: vsg60_iqin
  parameters:
    frequency: freq
    level: '-10'
    repeat: 'False'
    srate: samp_rate
  states: {}
- name: vsg60_iqin_0_0
  id: vsg60_iqin
  parameters:
    frequency: freq
    level: '-10'
    repeat: 'False'
    srate: samp_rate
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_1, '0', customModule_QPSK_Modulator_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_file_source_0, '0', vsg60_iqin_0_0, '0']
- [blocks_vector_source_x_0, '0', customModule_QPSK_Modulator_0, '0']
- [customModule_QPSK_Modulator_0, '0', customModule_upsampler_0, '0']
- [customModule_QPSK_Modulator_0, '0', qtgui_time_sink_x_0, '0']
- [customModule_QPSK_Modulator_0, '0', vsg60_iqin_0, '0']
- [customModule_upsampler_0, '0', root_raised_cosine_filter_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', root_raised_cosine_filter_1, '0']
- [digital_constellation_modulator_0, '0', vsg60_iqin_0, '0']
- [root_raised_cosine_filter_1, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_1, '0', vsg60_iqin_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
