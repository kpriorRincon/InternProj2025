options:
  parameters:
    generate_options: qt_gui
    id: data_to_vsg
    output_language: python
    title: vsg experimentation
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/empire/Documents/InternProj2025/hardware/data_for_sighound.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Tx"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Rx"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Real
    label2: Imaginary
    name: '"Tx"'
    size: '500'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Real
    label2: Imaginary
    name: '"Rx"'
    size: '500'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: vsg60_iqin_0
  id: vsg60_iqin
  parameters:
    frequency: freq
    level: '-10'
    repeat: 'False'
    srate: samp_rate
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', vsg60_iqin_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
