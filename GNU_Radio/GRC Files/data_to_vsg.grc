options:
  parameters:
    generate_options: qt_gui
    id: data_to_vsg
    output_language: python
    title: vsg experimentation
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/empire/Documents/InternProj2025/hardware/data_for_sighound.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: vsg60_iqin_0
  id: vsg60_iqin
  parameters:
    frequency: freq
    level: '-10'
    repeat: 'False'
    srate: samp_rate
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', vsg60_iqin_0, '0']

metadata:
  file_format: 1
