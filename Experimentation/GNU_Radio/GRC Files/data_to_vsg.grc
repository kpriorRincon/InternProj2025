options:
  parameters:
    generate_options: qt_gui
    id: data_to_vsg
    output_language: python
    title: vsg experimentation
  states: {}

blocks:
- name: freq_rx
  id: variable
  parameters:
    value: 920e6
  states: {}
- name: freq_tx
  id: variable
  parameters:
    value: 910e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/empire/Documents/InternProj2025/hardware/data_for_sighound.bin
    repeat: 'True'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq_rx
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq_tx
    gain: '10'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: vsg60_iqin_0
  id: vsg60_iqin
  parameters:
    frequency: freq_tx
    level: '0'
    repeat: 'False'
    srate: samp_rate
  states: {}

connections:
- [blocks_file_source_0, '0', vsg60_iqin_0, '0']
- [soapy_bladerf_source_0, '0', soapy_bladerf_sink_0, '0']

metadata:
  file_format: 1
