options:
  parameters:
    generate_options: qt_gui
    id: text_input_to_output
    output_language: python
    title: Text Input to Output
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/trevorwiseman/Documents/GitHub/InternProj2025/GNU_Radio/testing/bits_read_in.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/trevorwiseman/Documents/GitHub/InternProj2025/GNU_Radio/testing/bits_to_send.bin
    repeat: 'False'
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
