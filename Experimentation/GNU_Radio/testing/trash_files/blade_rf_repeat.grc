options:
  parameters:
    author: trevorwiseman
    generate_options: qt_gui
    id: blade_rf_repeat
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Imaginary"'
    size: '100'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Real"'
    size: '100'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '0']
- [soapy_bladerf_source_0, '0', blocks_complex_to_float_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_bladerf_source_0, '0', soapy_bladerf_sink_0, '0']

metadata:
  file_format: 1
