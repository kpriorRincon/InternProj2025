options:
  parameters:
    generate_options: qt_gui
    id: hardwaretest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: data
  id: variable
  parameters:
    value: (0,1,0,0,1,0,0,0,0,1,1,0,0,1,0,1,0,1,1,0,1,1,0,0,0,1,1,0,1,1,0,0,0,1,1,0,1,1,1,1,0,0,1,0,0,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,1,1,1,1,0,1,1,1,0,0,1,0,0,1,1,0,1,1,0,0,0,1,1,0,0,1,0,0,0,0,1,0,0,0,0,1)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: group_delay
  id: variable
  parameters:
    value: int(num_taps/2)
  states: {}
- name: marker
  id: variable
  parameters:
    value: (1,1,1,1,1,0,0,1,1,0,1,0,0,1,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,0,0,1)
  states: {}
- name: marker_offset
  id: variable
  parameters:
    value: tuple([0]*(int(skip/2)+1))
  states: {}
- name: modulated_marker
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: int(40)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: skip
  id: variable
  parameters:
    value: int((group_delay/2)*(sps/2))
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/empire/Documents/InternProj2025/GNU_Radio/testing/bits_read_in.bin
    type: int
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: skip
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: skip
    type: complex
  states: {}
- name: blocks_skiphead_0_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: group_delay
    type: int
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: marker+data
  states: {}
- name: customModule_QPSK_Demodulator_0
  id: customModule_QPSK_Demodulator
  parameters: {}
  states: {}
- name: customModule_QPSK_Modulator_0
  id: customModule_QPSK_Modulator
  parameters: {}
  states: {}
- name: customModule_downsampler_0
  id: customModule_downsampler
  parameters:
    sps: sps
  states: {}
- name: customModule_upsampler_0
  id: customModule_upsampler
  parameters:
    sps: sps
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Rx"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Tx"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imaginary
    name: '"Tx"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imaginary
    name: '"Rx"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: vsg60_iqin_0
  id: vsg60_iqin
  parameters:
    frequency: freq
    level: '-10'
    repeat: 'False'
    srate: samp_rate
  states: {}

connections:
- [blocks_skiphead_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', vsg60_iqin_0, '0']
- [blocks_skiphead_0_0, '0', customModule_downsampler_0, '0']
- [blocks_skiphead_0_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_source_x_0, '0', customModule_QPSK_Modulator_0, '0']
- [customModule_QPSK_Demodulator_0, '0', blocks_skiphead_0_0_0_0, '0']
- [customModule_QPSK_Modulator_0, '0', customModule_upsampler_0, '0']
- [customModule_QPSK_Modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [customModule_downsampler_0, '0', customModule_QPSK_Demodulator_0, '0']
- [customModule_downsampler_0, '0', qtgui_const_sink_x_0, '0']
- [customModule_upsampler_0, '0', root_raised_cosine_filter_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_skiphead_0_0, '0']
- [root_raised_cosine_filter_1, '0', blocks_skiphead_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', root_raised_cosine_filter_0, '0']

metadata:
  file_format: 1
