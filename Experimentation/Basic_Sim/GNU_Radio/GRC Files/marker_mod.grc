options:
  parameters:
    generate_options: qt_gui
    id: marker_mod
    output_language: python
    title: marker_mod
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: data
  id: variable
  parameters:
    value: (0,1,0,0,1,0,0,0,0,1,1,0,0,1,0,1,0,1,1,0,1,1,0,0,0,1,1,0,1,1,0,0,0,1,1,0,1,1,1,1,0,0,1,0,0,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,1,1,1,1,0,1,1,1,0,0,1,0,0,1,1,0,1,1,0,0,0,1,1,0,0,1,0,0,0,0,1,0,0,0,0,1)
  states: {}
- name: group_delay
  id: variable
  parameters:
    value: int(num_taps/2)
  states: {}
- name: marker
  id: variable
  parameters:
    value: (1,1,1,1,1,0,0,1,1,0,1,0,0,1,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,0,0,1)
  states: {}
- name: marker_offset
  id: variable
  parameters:
    value: tuple([0]*(int(skip/2)+1))
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: int(101)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: skip
  id: variable
  parameters:
    value: int((group_delay/2)*(sps/2))
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/empire/Documents/InternProj2025/GNU_Radio/testing/bits_read_in.bin
    type: int
  states: {state: disabled}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: skip
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: int
    vector: marker+data+data+marker_offset
  states: {}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: int
    vector: marker+data+data
  states: {}
- name: customModule_QPSK_Demodulator_0
  id: customModule_QPSK_Demodulator
  parameters: {}
  states: {state: disabled}
- name: customModule_QPSK_Modulator_0_0
  id: customModule_QPSK_Modulator
  parameters: {}
  states: {}
- name: customModule_QPSK_Modulator_0_0_0
  id: customModule_QPSK_Modulator
  parameters: {}
  states: {}
- name: customModule_downsampler_0
  id: customModule_downsampler
  parameters:
    sps: sps
  states: {state: disabled}
- name: customModule_upsampler_0_0
  id: customModule_upsampler
  parameters:
    sps: sps
  states: {}
- name: customModule_upsampler_0_0_0
  id: customModule_upsampler
  parameters:
    sps: sps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_grbackground_0
  id: qtgui_grbackground
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0,0,1,1)
    label1: Real
    label2: Imaginary
    name: '"Before RRC"'
    size: '448'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (1,0,1,1)
    label1: Real
    label2: Imaginary
    name: '"After RRC"'
    size: '448'
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}

connections:
- [blocks_skiphead_0_0, '0', customModule_downsampler_0, '0']
- [blocks_skiphead_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle_0_0, '0', customModule_QPSK_Modulator_0_0, '0']
- [blocks_throttle_0_0_0, '0', customModule_QPSK_Modulator_0_0_0, '0']
- [blocks_vector_source_x_1, '0', blocks_throttle_0_0, '0']
- [blocks_vector_source_x_1_0, '0', blocks_throttle_0_0_0, '0']
- [customModule_QPSK_Demodulator_0, '0', blocks_file_sink_0_0, '0']
- [customModule_QPSK_Modulator_0_0, '0', customModule_upsampler_0_0, '0']
- [customModule_QPSK_Modulator_0_0_0, '0', customModule_upsampler_0_0_0, '0']
- [customModule_downsampler_0, '0', customModule_QPSK_Demodulator_0, '0']
- [customModule_upsampler_0_0, '0', root_raised_cosine_filter_1_0, '0']
- [customModule_upsampler_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_1_0, '0', blocks_skiphead_0_0, '0']

metadata:
  file_format: 1
