options:
  parameters:
    generate_options: qt_gui
    id: data_to_vsg
    output_language: python
    title: vsg experimentation
  states: {}

blocks:
- name: freq_rx
  id: variable
  parameters:
    value: 920e6
  states: {}
- name: freq_tx
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/empire/Documents/InternProj2025/hardware/data_for_sighound.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/empire/Documents/InternProj2025/hardware/data_for_sighound.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_tx
    fftsize: '1024'
    name: '"Tx"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_tx
    fftsize: '1024'
    name: '"Tx"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imaginary
    name: '"Tx"'
    size: '500'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imaginary
    name: '"Tx"'
    size: '500'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq_rx
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_1
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq_rx
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq_tx
    gain: '30.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_1
  id: soapy_bladerf_source
  parameters:
    center_freq: freq_tx
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: vsg60_iqin_0
  id: vsg60_iqin
  parameters:
    frequency: freq_tx
    level: '0'
    repeat: 'False'
    srate: samp_rate
  states: {state: disabled}
- name: vsg60_iqin_1
  id: vsg60_iqin
  parameters:
    frequency: freq_tx
    level: '0'
    repeat: 'False'
    srate: samp_rate
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_1, '0', blocks_throttle_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', vsg60_iqin_0, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_throttle_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle_1, '0', vsg60_iqin_1, '0']
- [blocks_throttle_2, '0', soapy_bladerf_sink_1, '0']
- [soapy_bladerf_source_0, '0', blocks_throttle_0_0, '0']
- [soapy_bladerf_source_1, '0', blocks_throttle_2, '0']

metadata:
  file_format: 1
