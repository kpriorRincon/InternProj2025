options:
  parameters:
    generate_options: qt_gui
    id: simulation
    output_language: python
    realtime_scheduling: '1'
    title: simulation
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: data
  id: variable
  parameters:
    value: (0,1,0,0,1,0,0,0,0,1,1,0,0,1,0,1,0,1,1,0,1,1,0,0,0,1,1,0,1,1,0,0,0,1,1,0,1,1,1,1,0,0,1,0,0,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,1,1,1,1,0,1,1,1,0,0,1,0,0,1,1,0,1,1,0,0,0,1,1,0,0,1,0,0,0,0,1,0,0,0,0,1)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: group_delay
  id: variable
  parameters:
    value: int(num_taps/2)
  states: {}
- name: marker
  id: variable
  parameters:
    value: (1,1,1,1,1,0,0,1,1,0,1,0,0,1,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,0,0,1)
  states: {}
- name: marker_offset
  id: variable
  parameters:
    value: tuple([0]*(int(skip/2)+1))
  states: {}
- name: modulated_marker
  id: variable
  parameters:
    value: |-
      (-0.162794-0.195436j, -0.205587-0.206878j, -0.244216-0.186516j, -0.254743-0.157722j, -0.209717-0.148513j, -0.0954317-0.176885j, 0.05619-0.22366j, 0.181965-0.247448j, 0.220588-0.208159j, 0.145461-0.102616j, -0.00375595+0.038455j, -0.14837+0.157788j, -0.213419+0.205581j, -0.175588+0.159695j, -0.0590324+0.0458357j, 0.0807639-0.0872715j, 0.195449-0.195449j, 0.257974-0.251467j, 0.272338-0.259142j, 0.247074-0.23118j, 0.185101-0.177262j, 0.0834665-0.0928842j, -0.0445037+0.00980465j, -0.156794+0.113949j, -0.205825+0.190738j, -0.158646+0.224972j, -0.038819+0.210409j, 0.101901+0.174055j, 0.207276+0.150231j, 0.242049+0.165696j, 0.224443+0.202897j, 0.188335+0.227514j, 0.162175+0.202416j, 0.159211+0.119185j, 0.161785+0.000727935j, 0.162007-0.116039j, 0.166769-0.194844j, 0.182772-0.224201j, 0.216931-0.215366j, 0.241793-0.188264j, 0.21436-0.163386j, 0.1127-0.156278j, -0.0403838-0.168198j, -0.181545-0.184669j, -0.23315-0.189987j, -0.159771-0.184669j, 0.00495681-0.168198j, 0.173208-0.156278j,
      0.247753-0.160727j, 0.17506-0.189106j, -0.000727928-0.219486j, -0.178206-0.227841j, -0.250008-0.191462j, -0.178206-0.112162j, -0.000727926-5.87783e-09j, 0.17506+0.112162j, 0.247753+0.19412j, 0.173208+0.226998j, 0.00495681+0.215366j, -0.159771+0.185467j, -0.230491+0.16411j, -0.182388+0.160156j, -0.0445037+0.16747j, 0.10906+0.177645j)
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: int(40)
  states: {}
- name: offset
  id: variable
  parameters:
    value: tuple([0]*(int(skip/2)+1))
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,alpha,num_taps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.88e6
  states: {}
- name: skip
  id: variable
  parameters:
    value: int((group_delay/2)*(sps/2))
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/empire/Documents/InternProj2025/GNU_Radio/testing/bits_read_in.bin
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {state: disabled}
- name: blocks_skiphead_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: skip
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: int
    vector: marker+data+offset
  states: {}
- name: customModule_QPSK_Demodulator_0
  id: customModule_QPSK_Demodulator
  parameters: {}
  states: {state: disabled}
- name: customModule_QPSK_Modulator_0
  id: customModule_QPSK_Modulator
  parameters: {}
  states: {}
- name: customModule_downsampler_0
  id: customModule_downsampler
  parameters:
    sps: sps
  states: {state: disabled}
- name: customModule_upsampler_0
  id: customModule_upsampler
  parameters:
    sps: sps
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: sps
    symbols: modulated_marker
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: (2*np.pi)/100
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0.5'
    loop_bw: (2*np.pi)/100
    max_dev: '0.005'
    osps: sps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Rx"'
    size: '500'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Tx"'
    size: '500'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imag
    name: '"After Upsampling"'
    size: '500'
    srate: samp_rate
    style1: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: Real
    label2: Imag
    name: '"After RRC FIlter"'
    size: '500'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Real
    label2: Imaginary
    name: '"After Downsampling"'
    size: '500'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: '1'
    ntaps: num_taps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {state: disabled}

connections:
- [blocks_skiphead_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_skiphead_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle_0, '0', customModule_QPSK_Modulator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [customModule_QPSK_Demodulator_0, '0', blocks_null_sink_0, '0']
- [customModule_QPSK_Modulator_0, '0', customModule_upsampler_0, '0']
- [customModule_QPSK_Modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [customModule_downsampler_0, '0', customModule_QPSK_Demodulator_0, '0']
- [customModule_downsampler_0, '0', qtgui_const_sink_x_0, '0']
- [customModule_downsampler_0, '0', qtgui_time_sink_x_3, '0']
- [customModule_upsampler_0, '0', qtgui_time_sink_x_0, '0']
- [customModule_upsampler_0, '0', root_raised_cosine_filter_1, '0']
- [digital_corr_est_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', customModule_downsampler_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [root_raised_cosine_filter_1, '0', blocks_skiphead_0_0_0, '0']
- [virtual_source_0, '0', digital_corr_est_cc_0, '0']

metadata:
  file_format: 1
